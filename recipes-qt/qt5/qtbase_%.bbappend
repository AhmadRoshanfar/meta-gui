PACKAGECONFIG:append = " sql-sqlite eglfs"
